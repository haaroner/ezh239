# Keil uVision project test2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HSE,STM32F407xx,STM32F40_41xxx, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,HSE_VALUE = 8000000
  c include: ..\test_rtos_v10_3;.\src\cmsis;.\src\external;.\src\global_macros;.\src\main;.\src\spl4;.\src\spl4\inc;.\src\spl4\src;.\src\support_pacage;.\src\support_pacage\arm;.\src\support_pacage\gcc;.\src\support_pacage\gcc\linker;.\src\support_pacage\inc;.\RTOS;.\RTOS\include;.\src\time;.\src\Time
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/main/: main.cpp retarget.cpp RTE_Device.h startup_stm32f407xx.s FreeRTOSConfig.h project_config.h
    ./src/support_pacage/: system_stm32f4xx.c
  group SPL
    ./src/spl4/: stm32f4xx_conf.h
    ./src/spl4/inc/: stm32f4xx_rcc.h stm32f4xx_gpio.h stm32f4xx_syscfg.h stm32f4xx_tim.h
    ./src/spl4/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c misc.c stm32f4xx_adc.c
  group Time
    ./src/Time/: time.h time.cpp
  group GPIO
    ./src/GPIO/: GPIO.cpp GPIO.h
